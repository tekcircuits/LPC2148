# Keil uVision project main.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: project_hex +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\drv\include;..\include;..\module\include;..\app
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    ../drv/src/: adc.c uart0.c pll0.c buz.c led.c delay.c tri_colour.c I2C0.c switch.c Timer0_1.c uart1.c lcd.c
    ../app/: main.c app.c
    ../module/src/: gsm.c
